# Keil uVision project Smart_Remote_3_nRF52_Firmware_nRF52832.uvproj, settings and files
target PCA63519-SR3_nRF52832_Shield (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: PCA63519-SR3_nRF52832_Shield_Firmware +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: APP_SCHEDULER_ENABLED=1 ARM_MATH_CM4 BLE_STACK_SUPPORT_REQD CONFIG_BOARD_NRF52832_PCA63519 DISABLE_FLOAT_API ENABLE_ASSERTIONS FIXED_POINT FLOAT_ABI_HARD HAL_NFC_ENGINEERING_BC_FTPAN_WORKAROUND HAVE_ALLOCA_H HAVE_LRINT HAVE_LRINTF NRF52 NRF52832_XXAA NRF_SD_BLE_API_VERSION=5 OPUS_ARM_ASM OPUS_ARM_INLINE_ASM OPUS_ARM_INLINE_EDSP OPUS_ARM_INLINE_MEDIA OPUS_ARM_MAY_HAVE_EDSP OPUS_ARM_PRESUME_EDSP OPUS_BUILD S132 SOFTDEVICE_PRESENT SWI_DISABLE0 USE_ALLOCA USE_APP_CONFIG __STARTUP_CONFIG
  c misc: --c99 --reduce_paths --diag_suppress=4017
  c include: ..\..\..\Source\Bootloader;..\..\..\Source\Common;..\..\..\Source\Configuration;..\..\..\Source\Debug;..\..\..\Source\Drivers;..\..\..\Source\Libraries;..\..\..\Source\Libraries\bv32fp-1.2;..\..\..\Source\Libraries\opus-1.2.1;..\..\..\Source\Libraries\sbc-0025\include;..\..\..\Source\Modules;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\ble_flash;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\cli\ble_uart;..\..\..\..\..\..\components\libraries\cli\rtt;..\..\..\..\..\..\components\libraries\cli\uart;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\crypto\backend\cc310_lib;..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_crypto_sw;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_mpu;..\..\..\..\..\..\components\libraries\experimental_ringbuf;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_stack_guard;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\toolchain\cmsis\include;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc --cpreproc_opts=-D__ASSEMBLER__,-DCONFIG_BOARD_NRF52832_PCA63519
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x52000
  memory RVCT9: RAM 0x20002178 size 0xde88
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
    ../../../Source/Configuration/: sr3_config.c sr3_config_nrf52832_custom.h sr3_config_nrf52832_pca20023.h sr3_config_nrf52832_pca63519.h
  group Codec: ADPCM
    ../../../Source/Libraries/: dvi_adpcm.c
  group Codec: BV32FP
    ../../../Source/Libraries/bv32fp-1.2/: a2lsp.c allpole.c allzero.c autocor.c bitpack.c bvplc.c cmtables.c coarptch.c decoder.c encoder.c excdec.c excquan.c fineptch.c gaindec.c gainquan.c levdur.c levelest.c lsp2a.c lspdec.c lspquan.c ptdec.c ptquan.c stblchck.c stblzlsp.c tables.c utility.c
  group Codec: OPUS
    ../../../Source/Libraries/opus-1.2.1/: A2NLSF.c CNG.c HP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c LP_variable_cutoff.c LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c NLSF2A.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NSQ.c NSQ_del_dec.c PLC.c VAD.c VQ_WMat_EC.c ana_filt_bank_1.c analysis.c apply_sine_window_FIX.c autocorr_FIX.c bands.c biquad_alt.c burg_modified_FIX.c bwexpander.c bwexpander_32.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c check_control_input.c code_signs.c control_SNR.c control_audio_bandwidth.c control_codec.c corrMatrix_FIX.c cwrs.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_frame_FIX.c encode_indices.c encode_pulses.c entcode.c entdec.c entenc.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c gain_quant.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c k2a_FIX.c k2a_Q16_FIX.c kiss_fft.c laplace.c lin2log.c log2lin.c mathops.c mdct.c mlp.c mlp_data.c modes.c noise_shape_analysis_FIX.c opus.c opus_decoder.c opus_encoder.c opus_multistream.c opus_multistream_decoder.c opus_multistream_encoder.c pitch.c pitch_analysis_core_FIX.c pitch_est_tables.c process_NLSFs.c process_gains_FIX.c quant_LTP_gains.c quant_bands.c rate.c regularize_correlations_FIX.c repacketizer.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_IIR_FIR.c resampler_private_down_FIR.c resampler_private_up2_HQ.c resampler_rom.c residual_energy16_FIX.c residual_energy_FIX.c schur64_FIX.c schur_FIX.c shell_coder.c sigm_Q15.c sort.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_gain.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c vector_ops_FIX.c vq.c warped_autocorrelation_FIX.c
    ../../../Source/Libraries/opus-1.2.1/arm/: celt_pitch_xcorr_arm_keil.s
  group Codec: SBC
    ../../../Source/Libraries/sbc-0025/srce/: sbc_analysis.c sbc_dct.c sbc_dct_coeffs.c sbc_enc_bit_alloc_mono.c sbc_enc_bit_alloc_ste.c sbc_enc_coeffs.c sbc_encoder.c sbc_packing.c
  group Common
    ../../../Source/Common/: app_error_handler.c app_isched.c app_scheduler.c key_combo_util.c rng_monitor.c twi_common.c
  group Debug
    ../../../Source/Debug/: app_debug_pin.c stack_profiler_keil.s
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Drivers
    ../../../Source/Drivers/: drv_acc_lis3dh.c drv_audio_anr.c drv_audio_codec_adpcm.c drv_audio_codec_bv32fp.c drv_audio_codec_opus.c drv_audio_codec_sbc.c drv_audio_dsp.c drv_audio_pdm.c drv_board.c drv_buzzer.c drv_gyro_icm20608.c drv_ir_nec.c drv_ir_sirc.c drv_keyboard_matrix.c drv_keyboard_sx1509.c drv_leds_gpio.c drv_touchpad_synaptics.c drv_touchpad_mtch6102.c
  group Libraries
    ../../../Source/Libraries/: JLINK_MONITOR_ISR_ARM.s vocal_anr_keil.lib AIR_MOTION_Lib_3G3A_FULL_M4_KEIL.lib
  group Modules
    ../../../Source/Modules/: event_bus.c m_acc.c m_audio.c m_audio_frame.c m_batt_meas.c m_buzzer.c m_coms.c m_coms_ble.c m_coms_ble_addr.c m_coms_ble_adv.c m_coms_ble_atvv.c m_coms_ble_atvv_srv.c m_coms_ble_dfu.c m_coms_ble_hid.c m_coms_ble_lesc.c m_gyro.c m_init.c m_ir_tx.c m_keyboard.c m_leds.c m_nfc.c m_protocol_hid.c m_protocol_hid_state.c m_protocol_ir.c m_system_state.c m_touchpad.c
    ../../../Source/Debug/: m_audio_gauges.c m_audio_probe.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hids/: ble_hids.c
    ../../../../../../components/ble/ble_services/ble_ias/: ble_ias.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Core
    ../../../../../../components/libraries/experimental_mpu/: nrf_mpu.c
    ../../../../../../components/libraries/experimental_stack_guard/: nrf_stack_guard.c
  group nRF_Crypto
    ../../../../../../components/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group nRF_Crypto backends
    ../../../../../../components/libraries/crypto/backend/cc310_lib/: cc310_lib_ecdh.c cc310_lib_ecdsa.c cc310_lib_hash.c cc310_lib_init.c cc310_lib_keys.c cc310_lib_rng.c cc310_lib_shared.c
    ../../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ../../../../../../components/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/ble_flash/: ble_flash.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pdm/: nrf_drv_pdm.c
    ../../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../../../components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../components/libraries/ecc/: ecc.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../components/libraries/cli/: nrf_cli.c
    ../../../../../../components/libraries/cli/ble_uart/: nrf_cli_ble_uart.c
    ../../../../../../components/libraries/cli/rtt/: nrf_cli_rtt.c
    ../../../../../../components/libraries/cli/uart/: nrf_cli_uart.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/experimental_ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/twi_mngr/: nrf_twi_mngr.c
    ../../../../../../components/libraries/sha256/: sha256.c
    ../../../../../../components/libraries/experimental_task_manager/: task_manager.c task_manager_core_keil.s
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_NFC
    ../../../../../../components/nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../../components/nfc/ndef/connection_handover/ac_rec/: nfc_ac_rec.c
    ../../../../../../components/nfc/ndef/connection_handover/ble_oob_advdata/: nfc_ble_oob_advdata.c
    ../../../../../../components/nfc/ndef/connection_handover/common/: nfc_ble_pair_common.c
    ../../../../../../components/nfc/ndef/connection_handover/ble_pair_msg/: nfc_ble_pair_msg.c
    ../../../../../../components/nfc/ndef/connection_handover/ep_oob_rec/: nfc_ep_oob_rec.c
    ../../../../../../components/nfc/ndef/connection_handover/hs_rec/: nfc_hs_rec.c
    ../../../../../../components/nfc/ndef/connection_handover/le_oob_rec/: nfc_le_oob_rec.c
    ../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../components/nfc/t2t_lib/: nfc_t2t_lib_keil.lib
    ../../../../../../components/nfc/ndef/text/: nfc_text_rec.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_micro-ecc
    ../../../../../../external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nrf_cc310
    ../../../../../../external/nrf_cc310/lib/: cc310_keil_0.9.0.lib
target PCA20023-SR3_nRF52832_Product_Example (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: as above
  output: PCA20023-SR3_nRF52832_Product_Example +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: APP_SCHEDULER_ENABLED=1 ARM_MATH_CM4 BLE_STACK_SUPPORT_REQD CONFIG_BOARD_NRF52832_PCA20023 DISABLE_FLOAT_API ENABLE_ASSERTIONS FIXED_POINT FLOAT_ABI_HARD HAL_NFC_ENGINEERING_BC_FTPAN_WORKAROUND HAVE_ALLOCA_H HAVE_LRINT HAVE_LRINTF NRF52 NRF52832_XXAA NRF_SD_BLE_API_VERSION=5 OPUS_ARM_ASM OPUS_ARM_INLINE_ASM OPUS_ARM_INLINE_EDSP OPUS_ARM_INLINE_MEDIA OPUS_ARM_MAY_HAVE_EDSP OPUS_ARM_PRESUME_EDSP OPUS_BUILD S132 SOFTDEVICE_PRESENT SWI_DISABLE0 USE_ALLOCA USE_APP_CONFIG __STARTUP_CONFIG
  c misc: --c99 --reduce_paths --diag_suppress=4017
  c include: as above
  asm define: as above
  asm misc: --cpreproc --cpreproc_opts=-D__ASSEMBLER__,-DCONFIG_BOARD_NRF52832_PCA20023
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x52000
  memory RVCT9: RAM 0x20002178 size 0xde88
  link misc: --diag_suppress 6330
target CUSTOM-SR3_nRF52832_Custom_Board (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: as above
  output: CUSTOM-SR3_nRF52832_Custom_Board +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: APP_SCHEDULER_ENABLED=1 ARM_MATH_CM4 BLE_STACK_SUPPORT_REQD CONFIG_BOARD_NRF52832_CUSTOM DISABLE_FLOAT_API ENABLE_ASSERTIONS FIXED_POINT FLOAT_ABI_HARD HAL_NFC_ENGINEERING_BC_FTPAN_WORKAROUND HAVE_ALLOCA_H HAVE_LRINT HAVE_LRINTF NRF52 NRF52832_XXAA NRF_SD_BLE_API_VERSION=5 OPUS_ARM_ASM OPUS_ARM_INLINE_ASM OPUS_ARM_INLINE_EDSP OPUS_ARM_INLINE_MEDIA OPUS_ARM_MAY_HAVE_EDSP OPUS_ARM_PRESUME_EDSP OPUS_BUILD S132 SOFTDEVICE_PRESENT SWI_DISABLE0 USE_ALLOCA USE_APP_CONFIG __STARTUP_CONFIG
  c misc: --c99 --reduce_paths --diag_suppress=4017
  c include: as above
  asm define: as above
  asm misc: --cpreproc --cpreproc_opts=-D__ASSEMBLER__,-DCONFIG_BOARD_NRF52832_CUSTOM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x52000
  memory RVCT9: RAM 0x20002178 size 0xde88
  link misc: --diag_suppress 6330
